# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\USART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\Motor;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE\ENMOTOR;..\HARDWARE\CONTOR;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\MENU;..\HARDWARE\PID;..\HARDWARE\protocol;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\GraySensor;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\filter;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\DMP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ENMOTOR/: encoder.c
    ../HARDWARE/CONTOR/: control.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/protocol/: protocol.c
    ../HARDWARE/PID/: bsp_pid.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/GraySensor/: bsp_graySensor.c
    ../HARDWARE/filter/: filter.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c dmpKey.h dmpmap.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../: readme.txt
